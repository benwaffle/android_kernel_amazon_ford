## drivers/misc/mediatek/cpu_stress/Kconfig
```kconfig
config MTK_CPU_STRESS
  bool CONFIG_MTK_CPU_STRESS
  default n
  help
    CONFIG_MTK_CPU_STRESS
```
